# Keil uVision project FDM001.uvproj, settings and files
target Timer01_M1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: FDM001 +hex
  AfterMake: "E:\work\steven\project\FDM001\tools  instruction\tools\hex2bin.exe"  E:\work\steven\project\FDM001\Output\FDM001.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Code\Include
  group Source
    ./Code/: FDM001.c init.c timer0_sysTick.c UART0.c UART1.c pwm.c spi.c queue.c voice.c fatidog.c key.c GPS.c licence.c systick.c
  group Common
    Code/Common/: Delay.c
    ./Code/Common/: Common.c
  group Startup
    Code/Startup/: STARTUP.A51
